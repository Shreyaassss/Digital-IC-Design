*** SPICE deck for cell Demo__Test__NAND2_2x{lay} from library Demo
*** Created on Thu Sep 26, 2024 16:02:53
*** Last revised on Thu Sep 26, 2024 16:45:08
*** Written on Thu Sep 26, 2024 16:45:20 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.01FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: Demo__Test__NAND2_2x{lay}
Mnmos@0 net@0 B_in#0nmos@0_poly-right gnd gnd nmos L=0.022U W=0.176U AS=0.005P AD=0.007P PS=0.29U PD=0.253U
Mnmos@1 Y A_in#0nmos@1_poly-right net@0 gnd nmos L=0.022U W=0.176U AS=0.007P AD=0.008P PS=0.253U PD=0.33U
Mnmos@2 gnd B#2nmos@2_poly-right net@38 gnd nmos L=0.022U W=0.044U AS=0.005P AD=0.005P PS=0.275U PD=0.29U
Mnmos@3 gnd net@38#8nmos@3_poly-right B_in gnd nmos L=0.022U W=0.044U AS=0.005P AD=0.005P PS=0.275U PD=0.29U
Mnmos@4 gnd A#2nmos@4_poly-right net@81 gnd nmos L=0.022U W=0.044U AS=0.005P AD=0.005P PS=0.275U PD=0.29U
Mnmos@5 gnd net@81#8nmos@5_poly-right A_in gnd nmos L=0.022U W=0.044U AS=0.005P AD=0.005P PS=0.275U PD=0.29U
Mpmos@0 Y B_in#2pmos@0_poly-left vdd vdd pmos L=0.022U W=0.176U AS=0.008P AD=0.008P PS=0.365U PD=0.33U
Mpmos@1 vdd A_in#3pmos@1_poly-left Y vdd pmos L=0.022U W=0.176U AS=0.008P AD=0.008P PS=0.33U PD=0.365U
Mpmos@2 vdd B#0pmos@2_poly-left net@38 vdd pmos L=0.022U W=0.088U AS=0.005P AD=0.008P PS=0.275U PD=0.365U
Mpmos@3 vdd net@38#6pmos@3_poly-left B_in vdd pmos L=0.022U W=0.088U AS=0.005P AD=0.008P PS=0.275U PD=0.365U
Mpmos@4 vdd A#0pmos@4_poly-left net@81 vdd pmos L=0.022U W=0.088U AS=0.005P AD=0.008P PS=0.275U PD=0.365U
Mpmos@5 vdd net@81#6pmos@5_poly-left A_in vdd pmos L=0.022U W=0.088U AS=0.005P AD=0.008P PS=0.275U PD=0.365U
** Extracted Parasitic Capacitors ***
C0 Y 0 0.143fF
C1 B_in 0 0.239fF
C2 A_in 0 0.145fF
C3 net@38 0 0.145fF
C4 B 0 0.017fF
C5 net@81 0 0.145fF
C6 A 0 0.023fF
** Extracted Parasitic Resistors ***
R0 B_in#0nmos@0_poly-right B_in#0nmos@0_poly-right##0 7.233
R1 B_in#0nmos@0_poly-right##0 B_in#0nmos@0_poly-right##1 7.233
R2 B_in#0nmos@0_poly-right##1 B_in#1pin@12_polysilicon-1 7.233
R3 B_in#1pin@12_polysilicon-1 B_in#1pin@12_polysilicon-1##0 7.75
R4 B_in#1pin@12_polysilicon-1##0 B_in#2pmos@0_poly-left 7.75
R5 B_in#1pin@12_polysilicon-1 B_in#1pin@12_polysilicon-1##0 5.425
R6 B_in#1pin@12_polysilicon-1##0 B_in 5.425
R7 A_in#0nmos@1_poly-right A_in#1pin@13_polysilicon-1 7.75
R8 A_in#1pin@13_polysilicon-1 A_in#1pin@13_polysilicon-1##0 5.425
R9 A_in#1pin@13_polysilicon-1##0 A_in 5.425
R10 A_in#1pin@13_polysilicon-1 A_in#1pin@13_polysilicon-1##0 9.817
R11 A_in#1pin@13_polysilicon-1##0 A_in#1pin@13_polysilicon-1##1 9.817
R12 A_in#1pin@13_polysilicon-1##1 A_in#3pmos@1_poly-left 9.817
R13 B#0pmos@2_poly-left B#0pmos@2_poly-left##0 8.99
R14 B#0pmos@2_poly-left##0 B#0pmos@2_poly-left##1 8.99
R15 B#0pmos@2_poly-left##1 B#0pmos@2_poly-left##2 8.99
R16 B#0pmos@2_poly-left##2 B#0pmos@2_poly-left##3 8.99
R17 B#0pmos@2_poly-left##3 B#1pin@23_polysilicon-1 8.99
R18 B#1pin@23_polysilicon-1 B#1pin@23_polysilicon-1##0 8.99
R19 B#1pin@23_polysilicon-1##0 B#1pin@23_polysilicon-1##1 8.99
R20 B#1pin@23_polysilicon-1##1 B#1pin@23_polysilicon-1##2 8.99
R21 B#1pin@23_polysilicon-1##2 B#1pin@23_polysilicon-1##3 8.99
R22 B#1pin@23_polysilicon-1##3 B#2nmos@2_poly-right 8.99
R23 B#1pin@23_polysilicon-1 B 9.3
R24 net@38#6pmos@3_poly-left net@38#6pmos@3_poly-left##0 8.99
R25 net@38#6pmos@3_poly-left##0 net@38#6pmos@3_poly-left##1 8.99
R26 net@38#6pmos@3_poly-left##1 net@38#6pmos@3_poly-left##2 8.99
R27 net@38#6pmos@3_poly-left##2 net@38#6pmos@3_poly-left##3 8.99
R28 net@38#6pmos@3_poly-left##3 net@38#7pin@35_polysilicon-1 8.99
R29 net@38#7pin@35_polysilicon-1 net@38#7pin@35_polysilicon-1##0 8.99
R30 net@38#7pin@35_polysilicon-1##0 net@38#7pin@35_polysilicon-1##1 8.99
R31 net@38#7pin@35_polysilicon-1##1 net@38#7pin@35_polysilicon-1##2 8.99
R32 net@38#7pin@35_polysilicon-1##2 net@38#7pin@35_polysilicon-1##3 8.99
R33 net@38#7pin@35_polysilicon-1##3 net@38#8nmos@3_poly-right 8.99
R34 net@38#7pin@35_polysilicon-1 net@38 9.3
R35 A#0pmos@4_poly-left A#0pmos@4_poly-left##0 8.99
R36 A#0pmos@4_poly-left##0 A#0pmos@4_poly-left##1 8.99
R37 A#0pmos@4_poly-left##1 A#0pmos@4_poly-left##2 8.99
R38 A#0pmos@4_poly-left##2 A#0pmos@4_poly-left##3 8.99
R39 A#0pmos@4_poly-left##3 A#1pin@48_polysilicon-1 8.99
R40 A#1pin@48_polysilicon-1 A#1pin@48_polysilicon-1##0 8.99
R41 A#1pin@48_polysilicon-1##0 A#1pin@48_polysilicon-1##1 8.99
R42 A#1pin@48_polysilicon-1##1 A#1pin@48_polysilicon-1##2 8.99
R43 A#1pin@48_polysilicon-1##2 A#1pin@48_polysilicon-1##3 8.99
R44 A#1pin@48_polysilicon-1##3 A#2nmos@4_poly-right 8.99
R45 A#1pin@48_polysilicon-1 A 9.3
R46 net@81#6pmos@5_poly-left net@81#6pmos@5_poly-left##0 8.99
R47 net@81#6pmos@5_poly-left##0 net@81#6pmos@5_poly-left##1 8.99
R48 net@81#6pmos@5_poly-left##1 net@81#6pmos@5_poly-left##2 8.99
R49 net@81#6pmos@5_poly-left##2 net@81#6pmos@5_poly-left##3 8.99
R50 net@81#6pmos@5_poly-left##3 net@81#7pin@60_polysilicon-1 8.99
R51 net@81#7pin@60_polysilicon-1 net@81#7pin@60_polysilicon-1##0 8.99
R52 net@81#7pin@60_polysilicon-1##0 net@81#7pin@60_polysilicon-1##1 8.99
R53 net@81#7pin@60_polysilicon-1##1 net@81#7pin@60_polysilicon-1##2 8.99
R54 net@81#7pin@60_polysilicon-1##2 net@81#7pin@60_polysilicon-1##3 8.99
R55 net@81#7pin@60_polysilicon-1##3 net@81#8nmos@5_poly-right 8.99
R56 net@81#7pin@60_polysilicon-1 net@81 9.3

* Spice Code nodes in cell cell 'Demo__Test__NAND2_2x{lay}'
.include "D:\DIC\22nm_HP.pm"
.params vdd = 0.8
v1 vdd gnd DC {vdd}
v2 A gnd PWL(0 0 400p 0 500p {vdd} 900p {vdd} 1n 0 1.4n 0 1.5n {vdd} 1.9n {vdd} 2n 0)
v3 B gnd PWL(0 0 900p 0 1n {vdd} 1.9n {vdd} )
.meas tran tPHL
+trig v(a_in) val={vdd/2} cross=3
+targ v(y) val={vdd/2} cross=1
.meas tran tPLH
+trig v(a_in) val={vdd/2} cross=4
+targ v(y) val={vdd/2} cross=2
.trans 0 2.4n
.END
